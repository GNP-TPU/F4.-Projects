# Keil uVision project LW1.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32H747XIHx:CM4 STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x10000000,0x00048000) IROM(0x08100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: LW1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=2
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x48000
  group Source Group 1
    ./: main.cpp RCC.cpp Interrupt_Handler.cpp
  group Headers
    ./: main.h RCC.h Interrupt_Handler.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.11.0
