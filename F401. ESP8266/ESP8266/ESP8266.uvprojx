# Keil uVision project ESP8266.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ESP8266
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Headers
    ./: DHT11.h main.h TIM.h UART.h ESP-01.h
  group Main Group
    ./: DHT11.c main.c TIM.c UART.c ESP-01.c
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
