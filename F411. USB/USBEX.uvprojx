# Keil uVision project USBEX.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USBEX
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: main.c stm32f4xx_it.c tm_stm32f4_usb_hid_device.c usb_bsp.c usb_core.c usb_dcd.c usb_dcd_int.c usbd_core.c usbd_desc.c usbd_hid_core.c usbd_ioreq.c usbd_req.c usbd_usr.c
  group Headers
    ./: defines.h main.h stm32f4xx_conf.h stm32f4xx_it.h tm_stm32f4_usb_hid_device.h usb_bsp.h usb_conf.h usb_core.h usb_dcd.h usb_dcd_int.h usb_defines.h usb_regs.h usbd_conf.h usbd_core.h usbd_def.h usbd_desc.h usbd_hid_core.h usbd_ioreq.h usbd_req.h usbd_usr.h
software components: CMSIS:CORE 6.1.1, CMSIS:OS Tick:SysTick 1.0.5, Device:Startup 2.6.3
