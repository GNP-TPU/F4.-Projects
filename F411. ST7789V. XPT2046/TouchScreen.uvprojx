# Keil uVision project TouchScreen.uvprojx, settings and files
target TouchScreenTarget (6240000::V6.24::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TouchScreen
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: DMA.c FLASH.c GPIO.c I2C.c Interrupt_Handlers.c main.c RCC.c SPI.c ST77xx.c TIM.c UART.c XPT2046.c
  group Headers
    ./: DMA.h FLASH.h GPIO.h I2C.h Interrupt_Handlers.h main.h RCC.h SPI.h ST77xx.h TIM.h UART.h XPT2046.h
software components: CMSIS:CORE 6.1.1, Device:Startup 2.6.3
