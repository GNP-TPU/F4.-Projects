# Keil uVision project RFID_UID_Changer.uvprojx, settings and files
target Current Target (6220000::V6.22::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RFID_UID_Changer
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: DMA.c Flash.c GPIO.c I2C.c Interrupt_Handlers.c main.c ModBus.c RC522.c RCC.c SPI.c TIM.c UART.c ST77xx.c
  group Headers
    ./: DMA.h Flash.h GPIO.h I2C.h Interrupt_Handlers.h main.h ModBus.h RC522.h RCC.h SPI.h TIM.h UART.h ST77xx.h
software components: CMSIS:CORE 6.1.1, Device:Startup 2.6.3
